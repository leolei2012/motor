# Keil uVision project project.uvprojx, settings and files
target project (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g474vet6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\bsp\include;..\..\hal;..\..\third_party\filter\include;..\..\third_party\pid\include;..\..\drivers;..\..\drivers\ain_sensor\include;..\..\app;..\..\app\alarm_system\include;..\..\config;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Include;..\..\utils\alarm\include;..\..\utils\check_algorithm\include;..\..\utils\debug\include;..\..\utils\ntc_temp\include;..\..\utils\platform\include;..\..\utils\rcm\include;..\..\utils\ring_buffer\include
  memory RVCT4: ROM 0x8000000 size 0x39800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ../../bsp/src/: bsp_board.c system_stm32g4xx.c main.c bsp_isr.c
    ../../bsp/startup/: startup_stm32g474xx.s
  group hal
    ../../hal/: hal.c hal_adc1.c hal_gpio.c hal_tim6.c
  group utils
    ../../utils/platform/src/: platform.c
    ../../utils/alarm/src/: alarm.c
    ../../third_party/filter/src/: filter.c
    ../../third_party/pid/src/: pid_controller.c
  group drivers
    ../../drivers/: drv.c
    ../../drivers/ain_sensor/src/: drv_ain_sensor.c
  group mcal/STM32G4xx_HAL_Driver
    ../../mcal/STM32Cube_FW_G4_V1.6.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_tim.c stm32g4xx_ll_utils.c
  group third_party/pid
    ../../third_party/pid/src/: pid_float.c
software components: CMSIS:CORE 5.6.0

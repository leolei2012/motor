# Keil uVision project project.uvprojx, settings and files
target project (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g474vet6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G474xx,TX_INCLUDE_USER_DEFINE_FILE
  c include: ..\..\bsp\include;..\..\hal;..\..\third_party\filter\include;..\..\third_party\pid\include;..\..\drivers;..\..\drivers\ain_sensor\include;..\..\drivers\output\include;..\..\drivers\uart\include;..\..\drivers\motor\include;..\..\app;..\..\app\alarm_system\include;..\..\app\led\include;..\..\config;..\..\rtos;..\..\rtos\threadx-6.5.1.202602a_rel\common\inc;..\..\rtos\threadx-6.5.1.202602a_rel\ports\cortex_m4\ac6\inc;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Include;..\..\middleware;..\..\middleware\debug_monitor\include;..\..\third_party\uart_control\include;..\..\third_party\mb_rtu\include;..\..\third_party\mcl\include;..\..\utils\alarm\include;..\..\utils\check_algorithm\include;..\..\utils\debug\include;..\..\utils\ntc_temp\include;..\..\utils\platform\include;..\..\utils\rcm\include;..\..\utils\ring_buffer\include
  memory RVCT4: ROM 0x8000000 size 0x39800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ../../bsp/src/: bsp_board.c system_stm32g4xx.c main.c bsp_isr.c bsp_threadx_low_level.c
    ../../bsp/startup/: startup_stm32g474xx.s
  group hal
    ../../hal/: hal.c hal_adc1.c hal_adc2.c hal_cordic.c hal_gpio.c hal_tim1.c hal_tim6.c hal_tim7.c hal_usart2.c
  group utils
    ../../utils/platform/src/: platform.c
    ../../utils/alarm/src/: alarm.c
    ../../third_party/filter/src/: filter.c
    ../../third_party/pid/src/: pid_controller.c
  group drivers
    ../../drivers/: drv.c
    ../../drivers/ain_sensor/src/: drv_ain_sensor.c
    ../../drivers/output/src/: drv_output.c
    ../../drivers/uart/src/: drv_uart.c
    ../../drivers/motor/src/: drv_motor.c
  group middleware
    ../../middleware/: middleware.c
    ../../middleware/debug_monitor/src/: debug_monitor.c dm_adapter.c dm_motor.c
  group app
    ../../app/: app.c app_task.c
    ../../app/alarm_system/src/: app_alarm_system.c
    ../../app/led/src/: app_led.c
  group mcal/STM32G4xx_HAL_Driver
    ../../mcal/STM32Cube_FW_G4_V1.6.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_tim.c stm32g4xx_ll_utils.c stm32g4xx_ll_cordic.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_usart.c
  group third_party/mb_rtu
    ../../third_party/mb_rtu/src/: modbus_common.c modbus_slave.c modbus_master.c
  group third_party/uart_control
    ../../third_party/uart_control/src/: uart_control.c
  group third_party/mcl
    ../../third_party/mcl/src/: mcl.c mcl_bldc_comm.c mcl_calibration.c mcl_config.c mcl_foc.c mcl_math.c mcl_mtpa_fw.c mcl_observer.c mcl_observer_flux.c mcl_observer_ortega.c mcl_observer_smo.c mcl_pid.c mcl_pll.c mcl_protection.c mcl_svpwm.c mcl_transform.c
  group third_party/pid
    ../../third_party/pid/src/: pid_float.c
  group rtos/threadx
    ../../rtos/threadx-6.5.1.202602a_rel/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_reset.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../rtos/threadx-6.5.1.202602a_rel/ports/cortex_m4/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
software components: CMSIS:CORE 5.6.0
